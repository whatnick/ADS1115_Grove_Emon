# Repository whatnick/ADS1115_Grove_Emon

## EAGLE design ADS1115_Grove_Emon.brd

Parts:
0X4A, 0X4B, 0X48, 0X49: SJ
C1, C2: 1µF; 0603
FB1, FB2: MMZ2012Y152B; 0603
J1, J2: ST-PJ-312; AUDIO6P-SMD-3.5-14.0X6.4X5.0MM
J3, J4: H4P-SMD-2.0; HW4-SMD-2.0
JP1: HEADER-1X1070MIL; 1X10_ROUND70
R1, R2, R3, R4: 10K; 0603
R5, R6: 100R; 0603
U1: ADS1115IDGST; MSOP10

Connections:
3V3: C2.1, FB1.1, J3.3, J4.3, JP1.10
ADDR: 0X4A.1, 0X4B.1, 0X48.1, 0X49.1, JP1.6, R3.1, U1.1 (ADDR)
AGND: C2.2, FB2.1, J3.4, J4.4, JP1.9
AIN0: J1.COM1, JP1.4, R6.1, U1.4 (AIN0)
AIN1: J1.L, JP1.3, R6.2, U1.5 (AIN1)
AIN2: J2.COM1, JP1.2, R5.1, U1.6 (AIN2)
AIN3: J2.L, JP1.1, R5.2, U1.7 (AIN3)
ALERT: JP1.5, R4.2, U1.2 (ALERT)
GND: 0X48.2, C1.1, FB2.2, J3.SS1, J3.SS2, J4.SS1, J4.SS2, R3.2, U1.3 (GND)
SCL: 0X4B.2, J3.1, J4.1, JP1.8, R1.2, U1.10 (SCL)
SDA: 0X4A.2, J3.2, J4.2, JP1.7, R2.2, U1.9 (SDA)
VDD: 0X49.2, C1.2, FB1.2, R1.1, R2.1, R4.1, U1.8 (VDD)

Notes on the sheet:
Default I²C Address = 1001000 (0x48)

Board: 2 copper layers, 38.0 x 20.4 mm, 20 parts (6 on the bottom side), 12 nets.

## Commit log

2015-12-03 Initial import
2015-12-03 v1 populated and routed
2015-12-10 Switched to SeeedStudio DRU
2015-12-25 Fixed grove connector orientation
2015-12-25 Moved label
2015-12-26 Back to oshpark.dru
2016-01-16 Joined 3V3 to VDD
2016-01-17 Upped Version to v3
2016-01-19 Rewired with 3V3 separated from VDD by ferrite
